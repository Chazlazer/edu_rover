Commit message: Add files via upload

File: my_edu_rover_description/urdf/base/base.gazebo.xacro (robot description, xacro)
@@ -6,4 +6,5 @@
       <mu1 value="0.05" />
       <mu2 value="0.05" />
+      <material>Gazebo/Blue</material>
     </gazebo>
   </xacro:macro>
