Commit message: Add files via upload

File: my_edu_rover_description/urdf/knuckle/knuckle.gazebo.xacro (robot description, xacro)
@@ -6,4 +6,5 @@
       <mu1 value="0.05" />
       <mu2 value="0.05" />
+      <material>Gazebo/White</material>
     </gazebo>
   </xacro:macro>
